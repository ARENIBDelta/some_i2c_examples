# IAR project i2c_slave_nbyte_interrupt.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\inc; ..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver Library
    ../STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_i2c.h
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_i2c.c
  group Include files
    ../inc/: stm8s_conf.h stm8s_it.h
  group Source files
    ../src/: main.c stm8s_it.c
